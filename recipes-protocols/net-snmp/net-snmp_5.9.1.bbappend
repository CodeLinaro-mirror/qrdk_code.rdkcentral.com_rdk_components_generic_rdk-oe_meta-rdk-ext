FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
SRC_URI += "file://CVE-2025-68615_5.9.1_fix.patch"

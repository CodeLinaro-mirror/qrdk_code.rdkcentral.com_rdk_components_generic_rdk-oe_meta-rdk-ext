EXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += " file://CVE-2022-24805_5.8_fix.patch \
	     file://CVE-2025-68615_5.8_fix.patch \
"

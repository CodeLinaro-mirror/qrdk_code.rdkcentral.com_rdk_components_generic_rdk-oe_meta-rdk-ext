FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://CVE-2026-5720_2.1_fix.patch"

